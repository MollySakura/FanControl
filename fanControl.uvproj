# Keil uVision project fanControl.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: FanController_v2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\FAN_V2.0;.\list
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c STC8G_H_EEPROM.c STC8G_H_Delay.c STC8G_H_ADC.c STC8H_PWM.c stc_usb_cdc_8h_xdata.LIB QC.c STC8G_H_NVIC.c
